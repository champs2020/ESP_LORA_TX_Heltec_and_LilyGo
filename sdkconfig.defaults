## sdkconfig.defaults
```kconfig
CONFIG_SCK_GPIO=5
CONFIG_MISO_GPIO=19
CONFIG_MOSI_GPIO=27
CONFIG_CS_GPIO=18
CONFIG_RST_GPIO=23
CONFIG_DIO0_GPIO=26
```
